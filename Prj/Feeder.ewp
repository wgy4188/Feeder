# IAR project Feeder.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: C:\Users\SR00357\Desktop\程序整理\Feeder\App; C:\Users\SR00357\Desktop\程序整理\Feeder\Bsp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Feeder.bin
  ILINK.IlinkOutputFile: Feeder.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../App/: main.c stm8s_it.c
